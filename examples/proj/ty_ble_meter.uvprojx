# Keil uVision project ty_ble_meter.uvprojx, settings and files
target tuya_ble_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_5_stack
  AfterMake: fromelf.exe  --text  -c -o host_app.txt  Objects/ble_5_stack.axf
  AfterMake: fromelf.exe  --bin -o host_app.bin  Objects/ble_5_stack.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_ADV_MEM_ALLOOC_NEW,CFG_SIMPLE_PRINTF, CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<custom_tuya_ble_config.h>
  c misc: --c99 --diag_suppress=177,550,186,545,188,68,1296,223
  c include: ..\..\components\ble\include;..\..\components\driver\include;..\..\components\modules\os\include;..\..\components\modules\sys\include;..\..\components\modules\platform\include;..\..\components\modules\common\include;..\..\components\modules\lowpow\include;..\..\components\modules\button;..\..\components\ble\include\gap;..\..\components\ble\include\gatt;..\..\components\ble\profiles\ble_ota;..\..\components\ble\profiles\ble_dev_info;..\..\components\ble\profiles\ble_batt;..\..\components\ble\profiles\ble_hid;..\code;..\code\app\inc;..\code\port;..\code\port\include;..\code\port\FR801xH\ota;..\code\port\FR801xH\service;..\code\port\FR801xH\tuya_ble_port;..\code\components\ty_oled;..\code\components\external\easylogger\inc;..\code\components\external\easylogger\plugins\file;..\code\components\external\easylogger\plugins\flash;..\code\tuya_ble_sdk;..\code\tuya_ble_sdk\app\product_test;..\code\tuya_ble_sdk\app\uart_common;..\code\tuya_ble_sdk\extern_components\mbedtls;..\code\tuya_ble_sdk\port;..\code\tuya_ble_sdk\sdk\include;..\code\tuya_ble_sdk\sdk\lib;..\code\middleware\inc;..\code\components\vfm\include;..\code\app\inc\vfm_inc;..\..\components\modules\adpcm_ms;..\..\components\modules\adpcm_ima;..\..\components\modules\decoder;..\code\components\rcu_433\include;..\code\tuya_ble_sdk\extern_components\cjson;..\code\ty_meter_sdk;..\code\ty_meter_sdk\kernel\inc;..\code\ty_meter_sdk\app\inc;..\code\ty_meter_sdk\components\vfm\include;..\code\ty_meter_sdk\middleware\inc;..\code\ty_meter_sdk\components\vfm\include;..\code\ty_meter_sdk\components\rcu_433\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_5_0_host_app.sct
  link misc: --feedback=feedback.txt ../code/syscall_tuya.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: main.c peripheral.c
    ../code/ty_meter_sdk/app/: locdef_config.c locdef_audio.c locdef_fsm.c locdef_service.c locdef_pin.c locdef_dp.c locdef_hid.c locdef_main.c
    ../code/ty_meter_sdk/app/device/: device_lock.c device_sensor.c device_vbat.c
  group profiles
    ../../components/ble/profiles/ble_batt/: batt_service.c
    ../../components/ble/profiles/ble_dev_info/: dev_info_service.c
    ../../components/ble/profiles/ble_hid/: hid_service.c
    ../code/port/FR801xH/service/: simple_gatt_service.c
  group ble_lib_plf
    ../../components/modules/platform/source/: app_boot_vectors.s core_cm3_isr.c
  group ble_lib_patch
    ../../components/modules/patch/: patch.c
    ../../components/ble/library/: fr8010h_stack.lib
  group driver
    ../../components/driver/: driver_iic.c driver_pmu.c driver_pmu_pwm.c driver_pmu_qdec.c driver_pwm.c driver_rtc.c driver_ssp.c driver_timer.c driver_uart.c driver_wdt.c driver_adc.c driver_codec.c driver_efuse.c driver_exti.c driver_i2s.c driver_keyscan.c
  group component/ty_oled
    ../code/components/ty_oled/: ty_oled.c
  group component/mbedtls
    ../code/tuya_ble_sdk/extern_components/mbedtls/: aes.c md5.c sha1.c sha256.c
  group component/easylogger
    ../code/components/external/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../code/components/external/easylogger/port/: elog_port.c
  group port
    ../code/port/FR801xH/ty_board_FR801xH/: ty_adc_FR801xH.c ty_ble_FR801xH.c ty_flash_FR801xH.c ty_i2c_FR801xH.c ty_pin_FR801xH.c ty_pwm_FR801xH.c ty_rtc_FR801xH.c ty_spi_FR801xH.c ty_system_FR801xH.c ty_timer_FR801xH.c ty_uart_FR801xH.c
    ../code/port/FR801xH/tuya_ble_port/: tuya_ble_port_FR801xH.c
    ../code/port/FR801xH/ota/: tuya_ble_ota.c
  group tuya_ble_sdk
    ../code/tuya_ble_sdk/sdk/src/: tuya_ble_api.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event.c tuya_ble_event_handler.c tuya_ble_event_handler_weak.c tuya_ble_feature_weather.c tuya_ble_gatt_send_queue.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_mutli_tsf_protocol.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_utils.c
    ../code/tuya_ble_sdk/app/uart_common/: tuya_ble_app_uart_common_handler.c
    ../code/tuya_ble_sdk/sdk/lib/: tuya_ble_sdk_lib_arm_m3_keil.lib
    ../code/tuya_ble_sdk/app/product_test/: tuya_ble_app_production_test.c
  group tuya_ble_sdk/extern_components
    ../code/tuya_ble_sdk/extern_components/cjson/: cJSON.c
  group ty_meter_sdk/kernel
    ../code/ty_meter_sdk/kernel/: tuya_kel_flash.c tuya_kel_audio.c tuya_kel_os.c tuya_kel_system.c tuya_kel_timer.c
    ../code/ty_meter_sdk/: tuya_log.c
  group ty_meter_sdk/port/kernel
    ../code/ty_meter_sdk/port/kernel/: tuya_kel_port_flash.c tuya_kel_port_audio.c tuya_kel_port_os.c tuya_kel_port_system.c tuya_kel_port_timer.c
    ../code/ty_meter_sdk/port/: tuya_port_log.c
  group ble/component
    ../../components/modules/adpcm_ms/: adpcm_ms.c
  group ty_meter_sdk/middleware
    ../code/ty_meter_sdk/middleware/: tuya_mid_nv.c tuya_mid_dev.c tuya_mid_power_mgr.c
  group ty_meter_sdk/components
    ../code/ty_meter_sdk/components/vfm/: vfm_base.c vfm_log.c
    ../code/ty_meter_sdk/components/vfm/upload/: vfm_upload.c
    ../code/ty_meter_sdk/components/vfm/fsm/: vfm_fsm.c
    ../code/ty_meter_sdk/components/vfm/adapter/: vfm_lock.c vfm_sensor.c vfm_vbat.c
    ../code/ty_meter_sdk/components/rcu_433/protocol/: ev1527.c
    ../code/ty_meter_sdk/components/rcu_433/: rcu433_mgr.c rcu433_srv.c
software components: CMSIS:CORE 5.3.0
